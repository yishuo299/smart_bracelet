# Keil uVision project target.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: target +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: STM32F10X_MD,ARM_MATH_CM3,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\HARDWARE;..\HARDWARE\MQTT;..\HARDWARE\onenet\inc;..\DSPLIB\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../SYSTEM/sys/: sys.c
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/: key.c led.c beep.c driver.c lcd.c time3.c ds18b20.c max30102.c max30102_fir.c bluetooth.c asrpro.c ds1307.c watch_face.c ad8232.c ecg_display.c wave_display.c
  group DSP
    ../DSPLIB/: arm_cortexM3l_math.lib
